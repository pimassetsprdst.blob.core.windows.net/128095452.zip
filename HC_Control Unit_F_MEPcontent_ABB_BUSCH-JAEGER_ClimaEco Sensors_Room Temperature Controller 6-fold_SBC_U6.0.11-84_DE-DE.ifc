Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project nummer
Time: 2018-10-23T12:05:27
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160720_1515(x64) - Exporter 17.0.501.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Oct 23 12:05:27 2018 * Host: B3ROBRAWR3853 * Database: C:\Users\LC\AppData\Local\Temp\{A748E2F2-4449-4A40-8419-97B62A2CD26D}\ifc * Database version: 5507 * Database creation date: Tue Oct 23 12:05:25 2018 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Tue Oct 23 12:05:26 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Oct 23 12:05:26 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project nummer
LongName: Project omschrijving; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuildingStorey, V00
LongName: V00; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Floor Level; Family and Type: Level: Floor Level; Type: Level: Floor Level; Type Id: Level: Floor Level
Identity Data - Type Name: Floor Level; Building Story: yes; Name: V00; Structural: no
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent: standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm

# IfcDistributionControlElement: SBC_U6.0.11-84, HC_Control Unit_F_MEPcontent_ABB_BUSCH-JAEGER_ClimaEco Sensors_Room Temperature Controller 6-fold_DE-DE:SBC_U6.0.11-84:1443266
In: V00
Type - Material: Color RAL 9016, Color RGB 224-224-224, Color RGB 040-040-040
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Depth: 13 mm; Height: 116 mm; Width: 90 mm
Type - Identity Data - Article Type: SBC/U6.0.11-84; Base Family Version: 11.19; Content Supplier URL: www.MEPcontent.com; Copyright: © Stabiplan International BV; Custom: no; Description: SBC/U6.0.11-84 HVAC/Co2-device, 6f CE; EMCS Version: 4.0; ETIM Article Class: EC000926; Family Version: 11.20; Manufacturer: ABB; Manufacturer URL: https://www.busch-jaeger-katalog.de/2CKA006330A0009,artikel.html; MEPcontent Class: CONTROL_UNIT; Model: SBC/U6.0.11-84; OmniClass Number: 23.75.65.11.11; OmniClass Title: Heating Controllers; Revit Version: 2017; Type Name: SBC_U6.0.11-84; URL: www.stabiplan.com; Watermarked By: www.stabiplan.com
Type - Materials and Finishes - Body: Color RAL 9016; Grey Screen: Color RGB 224-224-224; Screen: Color RGB 040-040-040
Type - Other - Category: Mechanical Equipment; Family Name: HC_Control Unit_F_MEPcontent_ABB_BUSCH-JAEGER_ClimaEco Sensors_Room Temperature Controller 6-fold_DE-DE
Type - Text - Article Description: SBC/U6.0.11-84 HVAC/Co2-device, 6f CE; GTIN: 4011395255186; Manufacturer Art. No.: 2CKA006330A0009; Product Line: KNX-User Operation - ClimaEco Sensors - 6 fold with Room Thermostat Co2
Pset_ManufacturerTypeInformation - Manufacturer: ABB
Constraints - Elevation: 0 mm
Dimensions - Area: 0.0269867 m2; Volume: 0.000177213 m3
Identity Data - Mark: 4
Mechanical - System Classification: Communication
Other - Box Connector: 36.032 mm; Family: HC_Control Unit_F_MEPcontent_ABB_BUSCH-JAEGER_ClimaEco Sensors_Room Temperature Controller 6-fold_DE-DE: SBC_U6.0.11-84; Family and Type: HC_Control Unit_F_MEPcontent_ABB_BUSCH-JAEGER_ClimaEco Sensors_Room Temperature Controller 6-fold_DE-DE: SBC_U6.0.11-84; Fitting: 10.032 mm; Flush Mount: yes; Type: HC_Control Unit_F_MEPcontent_ABB_BUSCH-JAEGER_ClimaEco Sensors_Room Temperature Controller 6-fold_DE-DE: SBC_U6.0.11-84; Type Id: HC_Control Unit_F_MEPcontent_ABB_BUSCH-JAEGER_ClimaEco Sensors_Room Temperature Controller 6-fold_DE-DE: SBC_U6.0.11-84; Void Offset: 26 mm
Phasing - Phase Created: 3. Nieuwbouw
Visibility - Anti-Theft Protection: no; Button End Strip: no; Cover RTC: no; Surface Box: no
